## package/brainfuck-driver/Config.in
```kconfig
config BR2_PACKAGE_BRAINFUCK_DRIVER
	bool "brainfuck driver"
	help
	  The brainfuck device driver
```
